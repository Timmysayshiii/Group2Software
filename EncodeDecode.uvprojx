# Keil uVision project EncodeDecode.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EncodeDecode
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c PLL.c UART.c PLL.h TExaS.h UART.h UniversalFunctions.c UniversalFunctions.h calculations.c calculations.h VincentyDistance.c vector.c UART1.c Rotation.c Heading.c VincentyDistance.h vector.h UART1.h Rotation.h Heading.h updatedNmeaFunctions.c updatedNmeaFunctions.h
software components: CMSIS:CORE 5.0.2, CMSIS:DSP 1.5.2, Device:Startup 1.0.1
